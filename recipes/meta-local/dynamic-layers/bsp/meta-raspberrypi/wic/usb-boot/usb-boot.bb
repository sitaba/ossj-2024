LICENSE = "closed"

DISTRO_FEATURES:append = " USB_BOOT"

WKS_FILE = "sdimage-raspberrypi-usb-boot.wks"
WKS_SEARCH_PATH = "${LAYERDIR}/dynamic-layers/bsp/meta-raspberrypi/wic"
