require recipes-platform/images/agl-image-weston.bb

SUMMARY = "AGL KVM demo guest weston image"
