require recipes-platform/images/agl-cluster-demo-qt.bb

SUMMARY = "AGL KVM demo guest cluster image Qt"
